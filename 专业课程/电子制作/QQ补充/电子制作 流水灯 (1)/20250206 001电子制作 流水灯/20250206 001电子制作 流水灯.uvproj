# Keil uVision project 20250206 001电子制作 流水灯.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 20250206 001电子制作 流水灯 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
